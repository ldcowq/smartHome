<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SimpleAPIExp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SimpleAPIExp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SimpleAPIExp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SimpleAPIExp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


